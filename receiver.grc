options:
  parameters:
    generate_options: qt_gui
    id: RX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: code_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: generator
  id: variable
  parameters:
    value: 1, 1, 0, 0, 1
  states: {}
- name: init
  id: variable
  parameters:
    value: '1, 1, 1, 1 '
  states: {}
- name: registers
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: samp_sym
  id: variable
  parameters:
    value: '64'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /output.dat
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 500e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 500e6
    fftsize: '1024'
    type: complex
  states: {}
- name: spread_cpfsk_demod_0
  id: spread_cpfsk_demod
  parameters:
    samples_per_symbol: samp_sym
  states: {}
- name: spread_rx_synthesizer_0
  id: spread_rx_synthesizer
  parameters:
    energy_threshold: '0.4'
    gen: generator
    high_freq: '12000'
    init: init
    sample_rate: samp_rate
    samples_per_hop: '32000'
    samples_per_symbol: '64'
    transition: 50e3
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: 500e6
    gain0: '47'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [spread_cpfsk_demod_0, '0', blocks_file_sink_0, '0']
- [spread_rx_synthesizer_0, '0', qtgui_freq_sink_x_0, '0']
- [spread_rx_synthesizer_0, '0', qtgui_waterfall_sink_x_0, '0']
- [spread_rx_synthesizer_0, '0', spread_cpfsk_demod_0, '0']
- [uhd_usrp_source_0, '0', spread_rx_synthesizer_0, '0']

metadata:
  file_format: 1
