options:
  parameters:
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: TX
  states: {}

blocks:
- name: code_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: generator
  id: variable
  parameters:
    value: 1, 1, 0, 0, 1
  states: {}
- name: init
  id: variable
  parameters:
    value: '1, 1, 1, 1 '
  states: {}
- name: registers
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: samp_sym
  id: variable
  parameters:
    value: '64'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,1,1,0,0,1,0,1,0,1,1,0,1,0,0,1,1,0,1,0,0,1,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,0,1,1,0,1,1,0,1,0,0,1,1,0,1,0,0,1,0,1,1,0,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,0,1,1,0,1,0,0,1,1,0,1,0,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,1,0,0,1,1,0,1,0,1,1,0)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 500e6
    fftsize: '1024'
    name: FFT Plot
    type: complex
  states: {}
- name: spread_cpfsk_mod_0
  id: spread_cpfsk_mod
  parameters:
    samples_per_symbol: samp_sym
  states: {}
- name: spread_synthesizer_0
  id: spread_synthesizer
  parameters:
    delay: '5000'
    gen: generator
    init: init
    sample_rate: samp_rate
    samples_per_hop: code_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 500e6
    gain0: '50'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', spread_synthesizer_0, '0']
- [blocks_vector_source_x_0, '0', spread_cpfsk_mod_0, '0']
- [spread_cpfsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [spread_synthesizer_0, '0', qtgui_freq_sink_x_0, '0']
- [spread_synthesizer_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
